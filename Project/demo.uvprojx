# Keil uVision project demo.uvprojx, settings and files
target curtain (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: curtain
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\Hardware\inc;..\User;..\User\inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLB
    ../Libraries/FWlib/src/: stm32f10x_gpio.c stm32f10x_usart.c misc.c stm32f10x_rcc.c
  group Hardwear
    ../Hardware/src/: hard_usart.c hard_finger.c
  group User
    ../User/: stm32f10x_it.c main.c stm32f10x_it.h stm32f10x_conf.h
    ../User/src/: cmd.c
